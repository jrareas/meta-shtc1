SRC_URI += "file://fragment.cfg;subdir=linux-5.10.61"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

